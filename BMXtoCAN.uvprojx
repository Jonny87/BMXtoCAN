# Keil uVision project BMXtoCAN.uvprojx, settings and files
target BMXtoCAN (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: BMXtoCAN
  c flags: Optim=1 OneElfS=1
  c define: USE_STM324xG_EVAL, STM32F4XX, USE_STDPERIPH_DRIVER,STM32F4XX USE_USB_OTG_FS
  c include: .\BMXtoCAN;.\STM32F4_libs\CMSIS;.\STM32F4_libs\MDK-ARM;.\STM32F4_libs\STM32F4xx_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: BMXtoCAN.sct
  group Source Files
    ./BMXtoCAN/: BMX055.c can1_interface.c I2C.c main.c stm32f4xx_it.c filter.c
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4_libs/STM32F4xx_StdPeriph_Driver/: misc.c stm32f4xx_can.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c
  group MDK-ARM
    ./STM32F4_libs/MDK-ARM/: startup_stm32f4xx.s
  group CMSIS
    ./STM32F4_libs/CMSIS/: system_stm32f4xx.c
